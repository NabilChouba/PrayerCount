# IAR project Backup of accl.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlff.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 300
  General.GHeapSize2: 50
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ../../../../../../../bluetooth/export/include; ../../../../../../../bluetooth/export/common_appl; ../../../../../../../bluetooth/export/accl_appl; ../../../../../../../bluetooth/private/protocols/common; ../../../../../../../bluetooth/private/protocols/hci_transport; ../../../../../../../bluetooth/private/protocols/dbase; ../../../../../../../bluetooth/private/protocols/el2cap; ../../../../../../../bluetooth/private/protocols/hci_1.2; ../../../../../../../bluetooth/private/protocols/sdp; ../../../../../../../bluetooth/private/protocols/rfcomm; ../../../../../../../bluetooth/private/protocols/sm; ../../../../../../../bluetooth/private/protocols/write_task; ../../../../../../../bluetooth/private/profiles/spp; ../../../../../../../bluetooth/private/platforms/spp/accl_arch/msp430; ../../../../../../../bluetooth/private/platforms/arch/msp430; ../../../../../../../bluetooth/private/platforms/arch/common; ../../../../../../../bluetooth/private/platforms/arch/msp430/msp430F5438/msp430F5438_hal; ../../../../../../../bluetooth/export/FreeRTOS/Source/include; ../../../../../../../bluetooth/export/FreeRTOS/Source/portable/IAR/MSP430; ../../../../../../../bluetooth/export/FreeRTOS/Demo/msp430_IAR
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: ../../../../../../../bluetooth/export/FreeRTOS/Demo/msp430_IAR
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ../../../../../../export/common_appl/: main.c
  group Accelerometer_Application
    ../../../../../../export/accl_appl/: accelerometer_pl.c appl_cb.c appl_menu_pl.c appl_sdk.c appl_spp.c sdk_config.h
    ../../../../../../export/common_appl/: appl_bt_rf.c
    ../../../../../../private/platforms/arch/msp430/: msp430_uart.c
    ../../../../../../private/platforms/spp/accl_arch/msp430/: sdk_pl.c user_task.c
  group BT_Stack _Lib
    ../../../lib/iar/: libspp_core.r43 libspp_pl.r43 libTI_init_script.r43
  group EZ430-RF2560_HAL
    ../../../../../../private/platforms/arch/msp430/msp430F5438/msp430f5438_hal/: hal_board.c hal_i2c.c hal_tlv.c hal_usb.c
  group FreeRTOS
    ../../../../../../export/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c
    ../../../../../../export/FreeRTOS/Source/portable/MemMang/: heap_2.c heap_bt.c
    ../../../../../../export/FreeRTOS/Source/portable/IAR/MSP430/: port.c portext.s43
